# Keil uVision project demo.uvproj, settings and files
target Target_1 (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: demo +hex
  link misc: REMOVEUNUSED
  group User
    ./: main.c config.h stc_usb_cdc_32g.LIB
  group Project
    ../Project/: led.c led.h beep.c beep.h timer.c timer.h smg.c smg.h hc595.c hc595.h
